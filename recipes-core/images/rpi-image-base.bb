require recipes-core/images/distro-image-base.bb


