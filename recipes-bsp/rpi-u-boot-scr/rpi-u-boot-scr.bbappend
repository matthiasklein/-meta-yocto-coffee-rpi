# overwrite boot.cmd.in
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

