FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0011-AArch64-Make-gdbserver-register-set-selection-dynamic.patch"

